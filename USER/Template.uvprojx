# Keil uVision project Template.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_USED=1
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\USER;..\HARDWARE\LED;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\HARDWARE\BEEP;..\HARDWARE\DHT11;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\ULTRASONIC;..\HARDWARE\MQ;..\HARDWARE\ADC;..\HARDWARE\BC28;..\HARDWARE\MG90S;..\HARDWARE\HC-SR;..\HARDWARE\OLED
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/ULTRASONIC/: ultrasonic.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/MQ/: mq.c
    ../HARDWARE/BC28/: bc28.c
    ../HARDWARE/HC-SR/: hc-sr501.c
    ../HARDWARE/MG90S/: mg90s.c
  group CORE
    ../CORE/: core_cm4.h core_cm4_simd.h startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group UCOSII-CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
